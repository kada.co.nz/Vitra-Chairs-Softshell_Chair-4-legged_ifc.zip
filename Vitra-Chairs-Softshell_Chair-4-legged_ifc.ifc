Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-04-10T02:36:16
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 10 02:36:16 2023 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\fba1fc5a-c3ee-4324-9a26-65d06c216866\dbc19fd9-8b91-40dc-9039-886ea1cd373b\ifc * Database version: 5507 * Database creation date: Mon Apr 10 02:36:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 10 02:36:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 10 02:36:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: Softshell Chair, Vitra-Chairs-Softshell_Chair-4-legged_rfa:Softshell Chair:15628
In: Level 1
Type - Material: anthracite, Black Aluminium powder-coated
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMstone; BIMObjectName: Vitra-Chairs-Softshell_Chair-4-legged_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Softshell Chair by Ronan and Erwan Bouroullec will surprise users with its exceptional comfort: flexible ribs are concealed in the back shell and adapt to the user, providing freedom of movement. The four-legged version of the elegant, lounge-style chair can be combined with a wide selection of dining tables.; Revision: 0; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 05/04/2023
Type - Identity Data - Collection: Bouroullec; Cost: 0; Description: The Softshell Chair by Ronan and Erwan Bouroullec will surprise users with its exceptional comfort: flexible ribs are concealed in the back shell and adapt to the user, providing freedom of movement. The four-legged version of the elegant, lounge-style chair can be combined with a wide selection of dining tables.; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Softshell Chair; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://static.vitra.com/media/asset/6690118/storage/master/download/Factsheet%2520Softshell%2520Chair-EN.pdf; Type Name: Softshell Chair; URL: https://www.vitra.com/en-be/living/product/details/softshell-chair-four-legged-base
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Chairs-Softshell_Chair-4-legged_rfa; Features: n/a; Finish: Material description Backrest and seat: flexible upper backrest shell. Seat and backrest shell in fibreglass-reinforced polyamide. Seat and backrest upholstery in polyurethane foam. Armrests are integrated in the seat shell. With two seams along the sides of the backrest. Four-star base: aluminium powder-coated in basic dark or with polished finish (swivel function with comfortable seat depth suspension).; Grade: n/a; ModelNumber: n/a; ModelReference: 42300600; Name: Chair-4-legged_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 565x620x815 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Construction - felt glides for hard floor: yes; glides for carpet: no
Dimensions - Area: 1.31608 m2; Volume: 0.285494 m3
Materials and Finishes - Base: Black Aluminium powder-coated; Colour of seat/backrest cover: anthracite
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Chairs-Softshell_Chair-4-legged_rfa: Softshell Chair; Family and Type: Vitra-Chairs-Softshell_Chair-4-legged_rfa: Softshell Chair; InstallationDate: n/a; Material: Metal, Textile and Leather; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Chairs-Softshell_Chair-4-legged_rfa: Softshell Chair; Type Id: Vitra-Chairs-Softshell_Chair-4-legged_rfa: Softshell Chair; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
